# IAR project Project.ewp, settings and files
configuration GD32F30X_CL (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_CL
  ICCARM.CCIncludePath2: F:\IAR Systems\GD32F30x_Firmware_Library_V2.2.0\Firmware\CMSIS; F:\IAR Systems\GD32F30x_Firmware_Library_V2.2.0\Firmware\CMSIS\GD\GD32F30x\Include; F:\IAR Systems\GD32F30x_Firmware_Library_V2.2.0\Firmware\GD32F30x_standard_peripheral\Include; ..\Utilities; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32F30X_XD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F303xG GD GD32F303xG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_XD
  ICCARM.CCIncludePath2: ..\..\Firmware; ..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\..\Utilities; ..
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F303xG.icf
configuration GD32F30X_HD (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\..\Utilities; ..
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F303xC.icf
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group CMSIS
    F:/IAR Systems/GD32F30x_Firmware_Library_V2.2.0/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../Utilities/: gd32f303e_eval.c
  group GD32F30x_Peripherals
    F:/IAR Systems/GD32F30x_Firmware_Library_V2.2.0/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    F:/IAR Systems/GD32F30x_Firmware_Library_V2.2.0/Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
