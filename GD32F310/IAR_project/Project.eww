<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\GD32F30X_CL\IAR_project\Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
