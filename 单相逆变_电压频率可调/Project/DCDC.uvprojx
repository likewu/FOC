# Keil uVision project DCDC.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DCDC +hex
  c flags: Optim=1
  c include: ..\Source\FWLib\inc;..\User;..\Source\qiankunLib\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../Source/Startup/: cortexm3_macro.s stm32f10x_vector.s
  group FWLib
    ../Source/FWLib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_calender.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group qiankunLib
    ../Source/qiankunLib/src/: qk_common.c qk_gpio.c qk_lcd.c qk_ssd1963.c qk_ili9320.c qk_pwm.c qk_adc.c qk_ir.c qk_menu.c qk_ft1505.c qk_ili8989.c
  group user
    ../User/: main.c Bipolar_PWM.c stm32f10x_it.c font.c sample.c pic.c
